Test Harness  for sky130_fd_sc_hd__buf_1
.include 'sky130nm.lib'
.include 'example/sky130_fd_sc_hd__buf_1/sky130_fd_sc_hd__buf_1.spice'
    .options savecurrents
    X1 A VGND VNB VPB VPWR X sky130_fd_sc_hd__buf_1
    * Power Supplies
    VVPWR VPWR 0 DC 1.8
VVPB VPB 0 DC 1.8
VVGND VGND 0 DC 0
VVNB VNB 0 DC 0
    * Signal Supplies
    VA A 0 PULSE(0 1.8 0 0.01n 0.01n 50ns 100ns)

    * CLoad
    CLoad X 0 1f
    * Control Generations
    .control
    let run  = 0
 foreach in_delay 0.01n 0.023n 0.0531329n 0.122474n 0.282311n 0.650743n 1.5n
    * Initiating Text Files in folder data
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/input_transition.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/cell_fall.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/cell_rise.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/fall_transition.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/rise_transition.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/rise_power.txt
    echo "input_transition:$in_delay" >> example/sky130_fd_sc_hd__buf_1/data/timing/fall_power.txt
    * 1.666 to match the slew rate
    let actual_rtime = $in_delay*1.666

    * Input Vector - Load Cap values(index2)
    foreach out_cap 0.0005000000p 0.0012632050p 0.0031913740p 0.0080627180p 0.0203697300p 0.0514622900p 0.1300148000p
        reset

        * Changing the V2 Supply Rise time as per the Input Rise Time vector
        alter @VA[pulse] = [ 0 1.8 0 $&actual_rtime $&actual_rtime 50ns 100ns ]

        * Changing the C1 value as per the foreach list
        alter CLOAD $out_cap

        tran 0.01n 300ns
        run

        reset
        * Verification of INPUT RISE TIME
        meas tran ts1 when v(A)=1.44 RISE=1
        meas tran ts2 when v(A)=0.36 RISE=1
        meas tran ts3 when v(A)=1.44 FALL=1
        meas tran ts4 when v(A)=0.36 FALL=1
        let RISE_IN_SLEW = (ts1-ts2)/1e-09
        let FALL_IN_SLEW = (ts4-ts3)/1e-09
        echo "actual_rise_slew:$&RISE_IN_SLEW" >> example/sky130_fd_sc_hd__buf_1/data/timing/input_transition.txt
        echo "actual_fall_slew:$&FALL_IN_SLEW" >> example/sky130_fd_sc_hd__buf_1/data/timing/input_transition.txt

        print run
        * Measuring Cell Fall Time @ 50% of VDD(1.8V)
        meas tran tinfall when v(A)=0.9 FALL=1
        meas tran tofall when v(X)=0.9 FALL=1
        let cfall = (tofall-tinfall)/1e-09
        if abs(cfall)>20
            meas tran tinfall when v(A)=0.9 Rise=1
            meas tran tofall when v(X)=0.9 FALL=1
            let cfall = abs(tofall-tinfall)/1e-09
        end
        print cfall
        echo "out_cap:$out_cap:cell_fall:$&cfall" >> example/sky130_fd_sc_hd__buf_1/data/timing/cell_fall.txt

        * Measuring Cell Rise Time @ 50% of VDD(1.8V)
        meas tran tinrise when v(A)=0.9 RISE=1
        meas tran torise when v(X)=0.9 RISE=1
        let crise = (torise-tinrise)/1e-09
        if abs(crise)>20
            meas tran tinrise when v(A)=0.9 FALL=1
            meas tran torise when v(X)=0.9 RISE=1
            let crise = abs(tinrise-torise)/1e-09
        end
        print crise
        echo "out_cap:$out_cap:cell_rise:$&crise" >> example/sky130_fd_sc_hd__buf_1/data/timing/cell_rise.txt

        * Measuring Fall transition Time @ 80-20% of VDD(1.8V)
        meas tran ft1 when v(X)=1.44 FALL=2
        meas tran ft2 when v(X)=0.36 FALL=2
        let fall_tran = (ft2-ft1)/1e-09
        print fall_tran
        echo "out_cap:$out_cap:fall_transition:$&fall_tran" >> example/sky130_fd_sc_hd__buf_1/data/timing/fall_transition.txt

        * Measuring Rise transition Time @ 20-80% of VDD(1.8V)
        meas tran rt1 when v(X)=1.44 RISE=2
        meas tran rt2 when v(X)=0.36 RISE=2
        let rise_tran = ((rt1-rt2)/1e-09)
        print rise_tran
        echo "out_cap:$out_cap:rise_transition:$&rise_tran" >> example/sky130_fd_sc_hd__buf_1/data/timing/rise_transition.txt
        * Set unate to 1 for positive_unate and 0 for negative_unate
        let pos_unate = 1
        let neg_unate = 0
        if pos_unate
            * Measuring Rising Power if Positive Unate
            meas tran pt1 when v(A)=0.1 RISE=2
            meas tran pt2 when v(X)=1.79 RISE=2
            * To avoid error due to peaks
            if pt1 > pt2
                meas tran pt2 when v(X)=1.79 RISE=3
            end
            let pwr_stc1 = (@CLOAD[i])*v(X)
            meas tran pwr_swt1 INTEG pwr_stc1 from=pt1 to=pt2
            let pwr_swt1 = pwr_swt1/1p
            echo "out_cap:$out_cap:power_switch:$&pwr_swt1" >> example/sky130_fd_sc_hd__buf_1/data/timing/rise_power.txt

            * Measuring Falling Power if Positive Unate
            meas tran pt1 when v(A)=1.79 FALL=2
            meas tran pt2 when v(X)=0.1 FALL=2
            let pwr_stc2 = (@CLOAD[i])*v(X) - (@(VVPWR#branch)*VPWR)
            meas tran pwr_swt2 INTEG pwr_stc2 from=pt1 to=pt2
            let pwr_swt2 = pwr_swt2/1p
            echo "out_cap:$out_cap:power_switch:$&pwr_swt2" >> example/sky130_fd_sc_hd__buf_1/data/timing/fall_power.txt
        end
        if neg_unate
            * Measuring Rising Power if Negative Unate
            meas tran pt1 when v(A)=1.75 FALL=2
            meas tran pt2 when v(X)=1.75 RISE=2
            if pt1 > pt2
                meas tran pt1 when v(A)=1.75 FALL=3
            end
            let pwr_stc1 = (@CLOAD[i])*v(X)
            meas tran pwr_swt1 INTEG pwr_stc1 from=pt1 to=pt2
            let pwr_swt1 = pwr_swt1/1p
            echo "out_cap:$out_cap:power_switch:$&pwr_swt1" >> example/sky130_fd_sc_hd__buf_1/data/timing/rise_power.txt

            * Measuring Falling Power if Negative Unate
            meas tran pt1 when v(A)=0.1 RISE=2
            meas tran pt2 when v(X)=0.1 RISE=2
            let pwr_stc2 = (@CLOAD[i])*v(X) - (@(VVPWR#branch)*VPWR)
            meas tran pwr_swt2 INTEG pwr_stc2 from=pt1 to=pt2
            let pwr_swt2 = pwr_swt2/1p
            echo "out_cap:$out_cap:power_switch:$&pwr_swt2" >> example/sky130_fd_sc_hd__buf_1/data/timing/fall_power.txt
        end
        let run = run + 1
        * plot a y
    end
    end
    rusage
    quit
    .endc
